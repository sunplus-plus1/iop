# Keil uVision project iop_8051.uvproj, settings and files
target Target 1 (MCS-51)
  device: DQ8051 Digital Core Design
  cpu: IRAM(0 - 0xFF) CLOCK(50000000)
  output: iop_8051 +hex
  AfterMake: ..\tools\srec_cat.exe  iop_8051.hex -Intel -byte-swap 4 -fill 0xff 0 65536 -o  iop_8051.bin -Binary
  AfterMake: ..\tools\bin2array.exe iop_8051.bin ../out/iopnormal.c
  c include: ..\include;..\include\common;..\include\driver\i2c
  group IOP_8051
    ../common/: Int_Vec.c SunReg.c timer.c vitrualserial.c
    ../driver/i2c/: i2c_slave.c i2c_slave_common.c
    ../startup/: startup.a51
    ../: normal_main.c
