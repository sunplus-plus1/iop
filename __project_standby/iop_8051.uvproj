# Keil uVision project iop_8051.uvproj, settings and files
target Target 1 (MCS-51)
  device: DQ8051 Digital Core Design
  cpu: IRAM(0 - 0xFF) CLOCK(50000000)
  output: iop_8051 +hex
  AfterMake: ..\tools\srec_cat.exe  iop_8051.hex -Intel -byte-swap 4 -fill 0xff 0 16384 -o  iop_8051.bin -Binary
  AfterMake: ..\tools\bin2array_standby.exe  iop_8051.bin ../out/iopstandby.c
  c define: STANDBY
  c include: ..\include;..\include\common;..\include\driver\i2c
  group IOP_8051
    ../common/: sunreg.c Int_Vec.c
    ../startup/: startup.a51
    ../: standby_main.c
